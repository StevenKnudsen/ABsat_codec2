options:
  parameters:
    author: Steven Knudsen
    copyright: University of Alberta 2022
    generate_options: qt_gui
    id: NS_codec2_decode_v01
    output_language: python
    title: Codec2 WAV decode
  states: {}

blocks:
- name: codec2_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: codec2_rate_scale
  id: variable
  parameters:
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: scale
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: wav_audio_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/knud/Development/AlbertaSat/ABsat_codec2/test_vectors/OSR_us_000_0061_8k_1200.dat
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: scale
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(codec2_rate/codec2_rate_scale)
    type: byte
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: decoded_audio_1200.wav
    format: FORMAT_WAV
    samp_rate: wav_audio_samp_rate
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The encoder does its best to pack bits into bytes. For example, at 1200 bps, the encode appears
      to take two 20 ms chunks and outputs 6 bytes. 6*8/1200 = 40 ms.

      This means that the decoder is tolerant of missing blocks of 6 bytes as long as they happen on
      6 byte boundaries.
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      Enable the top Rational Resampler and Audio Sink to hear the decoded audio.

      Note that unless those two blocks are enabled, the decoding will take less
      time than the encoded file duration.  A file 51s long will take < 5s to decode.

      Set wave_audio_samp_rate to the original WAV file (the one that was encoded)
      sample rate.

      Set codec2_rate to the rate selected in the CODEC2 Audio Encoder block.
      Set codec2_rate_scale to 50 for rates of 3200 and 2400 bps, to 25 for rates
      1200, 1300, 1400, and 1600.
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '.4'
    interp: int(samp_rate/wav_audio_samp_rate)
    type: fff
  states: {}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    mode: codec2.MODE_1200
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_short_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_stream_to_vector_0, '0', vocoder_codec2_decode_ps_0, '0']
- [rational_resampler_xxx_0_1, '0', audio_sink_1, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
