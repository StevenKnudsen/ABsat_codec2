options:
  parameters:
    author: Steven Knudsen
    copyright: University of Alberta 2022
    generate_options: qt_gui
    id: NS_codec2_encode_v01
    output_language: python
    title: Codec2 WAV encode
  states: {}

blocks:
- name: codec2_rate
  id: variable
  parameters:
    value: '1300'
  states: {}
- name: codec2_rate_scale
  id: variable
  parameters:
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: scale
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: wav_audio_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: male_8k_1300.dat
    type: byte
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: scale
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: int(codec2_rate/codec2_rate_scale)
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: female_male/male_8k.wav
    repeat: 'False'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Enable the top Rational Resampler and Audio Sink to hear the input WAV file.

      Note that unless those two blocks are enabled, the encoding will take less
      time than the WAV file duration.  A file 51s long will take < 5s to encode.

      Set wave_audio_samp_rate to the input WAV file sample rate.

      Set codec2_rate to the rate selected in the CODEC2 Audio Encoder block.
      Set codec2_rate_scale to 50 for rates of 3200 and 2400 bps, to 25 for rates
      1200, 1300, 1400, and 1600.
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      The encoder does its best to pack bits into bytes. For example, at 1300 bps, the encode appears
      to take two 40 ms chunks and outputs 13 bytes. 13*8/1300 = 80 ms.

      This means that the decoder is tolerant of missing blocks of 13 bytes as long as they happen on
      13 byte boundaries.
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '.4'
    interp: int(samp_rate/wav_audio_samp_rate)
    type: fff
  states: {state: disabled}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    mode: codec2.MODE_1300
  states: {}

connections:
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_short_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '0']
- [vocoder_codec2_encode_sp_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
